# To use NetworkManager instead
PACKAGECONFIG:remove = "networkd resolved nss-resolve"
