SYSTEMTAP:riscv64 = "systemtap"

RDEPENDS:${PN}:remove = "lttng-ust"
RDEPENDS:${PN}:remove = "lttng-tools"
RDEPENDS:${PN}:remove = "lttng-modules"
RDEPENDS:${PN}:remove = "babeltrace"
