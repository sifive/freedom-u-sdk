PACKAGECONFIG:append:hifive-premier-p550 = " zstd"
