require demo-coreip-cli.inc

IMAGE_FEATURES += "dbg-pkgs"
