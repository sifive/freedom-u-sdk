require demo-coreip-xfce4.inc
