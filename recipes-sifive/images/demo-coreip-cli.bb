require recipes-sifive/images/demo-coreip-cli.inc
