require recipes-sifive/images/demo-coreip-xfce4.inc

IMAGE_FEATURES += "dbg-pkgs"
