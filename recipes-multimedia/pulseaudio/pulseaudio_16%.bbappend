PACKAGECONFIG:append:freedom-u-sdk = " autospawn-for-root"
