PACKAGECONFIG:append = " autospawn-for-root"
