SYSTEMD_AUTO_ENABLE:${PN} = "disable"
