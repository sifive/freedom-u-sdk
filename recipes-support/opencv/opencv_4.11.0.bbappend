# modules/python/src2/cv2.hpp:39:10: fatal error: numpy/ndarrayobject.h: No such file or directory
PACKAGECONFIG:remove = "python3"
