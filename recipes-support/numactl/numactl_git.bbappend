LDFLAGS:append = " -latomic"
