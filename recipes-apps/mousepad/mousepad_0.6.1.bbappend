PACKAGECONFIG:append = " spell"
