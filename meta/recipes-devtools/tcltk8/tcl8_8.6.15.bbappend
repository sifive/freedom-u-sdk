EXTRA_OECONF = "--enable-threads --disable-rpath --enable-man-suffix=tcl8"
