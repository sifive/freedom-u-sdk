FILES:mesa-megadriver = "${libdir}/dri/* ${datadir}/drirc.d"
