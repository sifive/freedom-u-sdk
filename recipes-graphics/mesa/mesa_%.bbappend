VULKAN_DRIVERS:append:riscv64:class-target = ",amd"
