PACKAGECONFIG:remove = "gstreamer"
