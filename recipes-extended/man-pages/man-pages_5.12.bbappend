ALTERNATIVE:${PN}:append = " crypt_r.3"
ALTERNATIVE_LINK_NAME[crypt_r.3] = "${mandir}/man3/crypt_r.3"
