RDEPENDS:${PN}:remove = "dhcpcd"
