COMPATIBLE_HOST = "(x86_64|aarch64|arm|riscv64)"
