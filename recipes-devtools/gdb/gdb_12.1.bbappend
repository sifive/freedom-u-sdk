PACKAGECONFIG:append:pn-gdb = " python tui xz"
