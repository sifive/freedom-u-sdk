EXTRA_OECONF = "--disable-rpath --enable-man-suffix=tcl9"
