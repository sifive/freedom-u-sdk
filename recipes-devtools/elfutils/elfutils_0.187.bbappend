PACKAGECONFIG:append = " bzip2 xz"
