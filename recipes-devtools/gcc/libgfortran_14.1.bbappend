INSANE_SKIP:${PN}-dbg = "buildpaths"
