SYSTEMD_AUTO_ENABLE:${PN}-sshd = "disable"
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
