FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fix_service.patch \
           "
