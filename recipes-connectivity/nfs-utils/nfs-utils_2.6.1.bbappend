SYSTEMD_AUTO_ENABLE:${PN}-client = "disable"
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
