PACKAGECONFIG:append:freedom-u-sdk = " nmtui"