PACKAGECONFIG:append:freedom-u-sdk = " nmtui"
PACKAGECONFIG:append:freedom-u-sdk-hf-premier-p550 = " nmtui"
